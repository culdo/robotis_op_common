Commit message: cleanify model dir.

File: robotis_op_description/robots/robotis_op_orig.urdf (robot description, URDF)
Before this commit: robot robotis_op2, 31 links, 30 joints
Links:
- link MP_BACK_L: mass 0.01 -> 0.010
- link MP_BACK_R: mass 0.01 -> 0.010
